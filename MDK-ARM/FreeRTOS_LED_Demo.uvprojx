# Keil uVision project FreeRTOS_LED_Demo.uvprojx, settings and files
target Target 1 ()
  device: ST
  group Source
    ./:    
